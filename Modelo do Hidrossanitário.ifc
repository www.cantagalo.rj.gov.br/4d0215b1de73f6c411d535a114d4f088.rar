Properties of the parts of a building model (IFC4), part 5 of 6

# IfcPipeSegment: Tubos - diâmetro interno comercial (714)
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede
 | PAV.01 | 5.34 | ø2" | 0.33 | ø60 | 43.46 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 43.4643 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 159.22 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 159.218 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 718.47 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 718.474 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 55.29 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 55.2949 cm
 | PAV.01 | 3.52 | ø1 1/4" | 0.24 | ø40 | 167.78 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 167.778 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 27.38 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 27.3844 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 216.7 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 216.701 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 23.84 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 23.839 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 42.26 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 42.2602 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 47.71 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 47.7099 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 305.14 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 305.145 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 26 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 26.0025 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 14.73 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 14.7259 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 19.2 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 19.1994 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 107.73 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 107.73 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 444.53 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 444.528 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 111.5 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 111.496 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 25.39 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 25.3883 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 758.25 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 758.253 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 13.3 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 13.2957 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 262.62 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 262.62 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 170.62 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 170.618 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 22.72 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 22.7182 cm
 | PAV.01 | 3.52 | ø1 1/4" | 0.24 | ø40 | 341.2 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 341.2 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 14.33 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 14.3322 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 28.13 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 28.1319 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 32.38 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 32.3812 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 89.92 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 89.9225 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 128.74 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 128.74 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 325.77 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 325.773 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 58.35 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 58.3498 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 37.23 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 37.2304 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 12.24 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 12.2356 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 363.9 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 363.9 cm
7 x  | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 237.8 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 237.8 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 237.9 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 237.9 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 30.34 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 30.3358 cm
2 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 23.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 23.6 cm
2 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 44.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.05 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 47.59 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 47.5886 cm
2 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 109.23 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 109.232 cm
2 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.615 cm
2 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.52 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.515 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 14.6 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 14.6 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 84.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 84.9 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 44.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 44.9 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 24.63 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 24.632 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 73.65 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 73.6498 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 14.28 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.2797 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 65.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.8 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 54.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 54.8024 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 69.33 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 69.3253 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 69.58 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 69.5753 cm
2 x  | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 26.45 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 26.45 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 14.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.8 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 86 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 86.3 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86.3034 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 44.04 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.0433 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 65.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.4 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 82.41 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 82.4136 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 32.56 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 32.5594 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 45.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 45.8 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 132.29 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 132.292 cm
8 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 96.5 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 96.5 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 4.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 4.4 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 98.65 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 98.6497 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 12.7 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.7 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 27.03 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 27.0302 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 92.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 92.25 cm
2 x  | PAV. 02 | 3.52 | ø1 1/4" | 0.24 | ø40 | 31.54 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 31.5351 cm
2 x  | PAV. 02 | 3.52 | ø1 1/4" | 0.24 | ø40 | 90.74 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 90.7351 cm
2 x  | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 91.65 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 91.65 cm
4 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 3.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 3.8 cm
2 x  | PAV. 02 | 3.52 | ø1 1/4" | 0.24 | ø40 | 84.4 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 84.4 cm
2 x  | PAV. 02 | 3.52 | ø1 1/4" | 0.24 | ø40 | 74.4 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 74.4 cm
 | PAV. 02 | 5.34 | ø2" | 0.33 | ø60 | 12.6 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 12.6 cm
 | PAV. 02 | 5.34 | ø2" | 0.33 | ø60 | 81.69 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 81.69 cm
 | PAV. 02 | 5.34 | ø2" | 0.33 | ø60 | 41.69 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 41.69 cm
 | PAV. 02 | 5.34 | ø2" | 0.33 | ø60 | 30.77 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 30.7662 cm
 | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 86.49 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 86.4939 cm
 | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.615 cm
4 x  | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 7 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 7 cm
 | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 8.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 8.615 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 75 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 75 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 75.14 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 75.1351 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 4.2 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 4.2 cm
4 x  | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 27.3 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 27.3 cm
2 x  | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 9.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.6 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 12.16 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 12.157 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 65.6 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 65.6 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 43.13 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 43.1328 cm
2 x  | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 84.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 84.9 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 114.15 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 114.15 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 24.85 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 24.8525 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 27.9 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 27.9 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 10.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.8 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 85.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 85.4 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 116 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 116 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 93.52 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 93.5247 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 63.32 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 63.3183 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 12.9 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.9 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 13.5 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 13.5 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 25.24 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 25.2393 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 27.04 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 27.0387 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 16.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 16.796 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 14.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.7409 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 147.85 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 147.854 cm
 | PAV. 02 | 6.66 | ø2 1/2" | 0.42 | ø75 | 365.85 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 365.85 cm
 | PAV. 02 | 6.66 | ø2 1/2" | 0.42 | ø75 | 374.95 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 374.95 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 151.07 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 151.073 cm
2 x  | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 9.53 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.5284 cm
2 x  | PAV. 02 | 3.52 | ø1 1/4" | 0.24 | ø40 | 26.29 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 26.2928 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 368.51 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 368.507 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 15.78 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 15.7766 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 18.88 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.877 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 360.28 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 360.277 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 115.55 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 115.546 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 117.79 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 117.793 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 240.28 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 240.284 cm
 | PAV. 02 | 5.34 | ø2" | 0.33 | ø60 | 330.51 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 330.511 cm
 | PAV. 02 | 5.34 | ø2" | 0.33 | ø60 | 23.6 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 23.6 cm
3 x  | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 237.8 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 237.8 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 17.3 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 17.2968 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 485.8 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 485.8 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 172.61 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 172.61 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 53.54 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 53.5378 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 21.21 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 21.2062 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 116.83 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 116.835 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 10.89 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 10.8936 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 18.05 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.0545 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 140.65 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 140.646 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 237.37 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 237.366 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 142.24 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 142.239 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 13.9 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 13.9049 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 350 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 350 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 15.1 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 15.1 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 65.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.4 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 82.41 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 82.4136 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 32.56 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 32.5594 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 45.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 45.8 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 132.29 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 132.292 cm
 | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 84.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 84.05 cm
 | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 62.07 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 62.065 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 10.6 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 10.6 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 44.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 44.9 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 31.2 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 31.1968 cm
 | PAV. 02 | 2.78 | ø1" | 0.21 | ø32 | 66.7 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 66.7 cm
 | PAV. 02 | 4.4 | ø1 1/2" | 0.3 | ø50 | 152.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 152.615 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 82.6 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 82.6003 cm
 | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 82.29 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 82.2919 cm
2 x  | PAV. 02 | 2.16 | ø3/4" | 0.17 | ø25 | 16.45 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 16.45 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 18.81 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 18.8103 cm
2 x  | COBERTURA 01 | 6.66 | ø2 1/2" | 0.42 | ø75 | 23.15 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 23.1502 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 382.15 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 382.146 cm
4 x  | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 64.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 64.6 cm
2 x  | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 65.2 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.2 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 60.9 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 60.9 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 33.55 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 33.55 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 39.14 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 39.1394 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 398.92 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 398.919 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 282.18 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 282.18 cm
2 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 59.8 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 59.8 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 29.14 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 29.1394 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 317.55 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 317.555 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 440.01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 440.011 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 356.04 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 356.043 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 19.14 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 19.1394 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 236.19 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 236.19 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 402.77 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 402.772 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 412.96 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 412.964 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 18.19 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 18.188 cm
2 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 8.09 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 8.09204 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 58.35 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 58.35 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 18.64 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 18.6394 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 242.68 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 242.681 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 30.47 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 30.4653 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 33.7 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 33.7 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 208.64 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 208.639 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 1775.76 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 1775.76 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 547.17 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 547.171 cm
2 x  | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 48.31 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 48.3062 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 33.16 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 33.1584 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 5.32 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 5.32403 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 29.01 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 29.0102 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 159.8 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 159.804 cm
 | COBERTURA 01 | 5.34 | ø2" | 0.33 | ø60 | 24.58 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 24.5788 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 17.24 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 17.2393 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 12.44 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.4433 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 32.43 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 32.433 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 63.67 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 63.6686 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 95.03 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 95.0323 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 21.84 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 21.8394 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 85.42 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 85.4218 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 37.19 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 37.1896 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 622.46 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 622.461 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 4.93 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 4.93394 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 258.57 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 258.572 cm
2 x  | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 176.66 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 176.66 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 186.3 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 186.3 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 28.79 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 28.7933 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 8.21 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 8.2057 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 11.9 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 11.9046 cm
3 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 3.17 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 3.16751 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 6.55 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 6.55435 cm
2 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 45.4 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 45.4 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 27.76 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 27.7625 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 50.96 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 50.9623 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 735.48 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 735.475 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 277.73 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 277.734 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 86.9 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86.9 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 5.7 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 5.69569 cm
2 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 39.49 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 39.4895 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 185.8 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 185.8 cm
 | COBERTURA 01 | 2.16 | ø3/4" | 0.17 | ø25 | 17.18 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 17.1802 cm
 | COBERTURA 01 | 6.66 | ø2 1/2" | 0.42 | ø75 | 74.77 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 74.7708 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 55.09 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 55.09 cm
2 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 8.53 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 8.53045 cm
2 x  | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 172.18 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 172.18 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 60.6 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 60.6 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.08 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.0839 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 78.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 78.0538 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 252.68 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 252.68 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 9.86 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.85991 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 186.24 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 186.238 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 5.55 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 5.55308 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 50.32 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 50.3235 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 22.96 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 22.9623 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 37 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 37.0022 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 1.94 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 1.94181 cm
 | COBERTURA 01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 5.57 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 5.56525 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 35.73 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 35.7332 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 26.82 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 26.8197 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 172.88 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 172.88 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 3.64 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 3.6357 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 48.35 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 48.35 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 112.82 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 112.817 cm
 | COBERTURA 01 | 7.56 | ø3" | 0.47 | ø85 | 290.3 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 290.301 cm
2 x  | COBERTURA 01 | 6.66 | ø2 1/2" | 0.42 | ø75 | 62.6 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 62.6 cm
 | COBERTURA 01 | 6.66 | ø2 1/2" | 0.42 | ø75 | 12.63 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 12.6309 cm

# IfcSanitaryTerminal: Bebedouro (15)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Bebedouro; Nome: 40mm; Classe: PVC Esgoto; Tipo: Bebedouro; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro
Name | In
4 x  | PATIO
2 x  | PATIO | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
 | TÉRREO | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
2 x  | TÉRREO
 | PAV.01 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
2 x  | PAV.01
2 x  | PAV. 02
 | PAV. 02 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Bebedouro com joelho de 90º (5)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: BE; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Bebedouro com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Bebedouro com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Bebedouro - 25mmx 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
2 x  | PATIO
 | TÉRREO
 | PAV.01
 | PAV. 02

# IfcSanitaryTerminal: Chuveiro (8)
In: PAV. 02
Type - PredefinedType: SHOWER
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: CH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Chuveiro; Nome: 25mm x 1/2"; Classe: PVC rígido soldável; Tipo: Chuveiro; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Chuveiro
AltoQi_QiBuilder-Itens_Associados - Aparelho - Chuveiro - 25mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Ducha Higiênica com Joelho de 90º (22)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: DH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Ducha Higiênica; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Ducha Higiênica com Joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Ducha Higiênica com Joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Ducha higiênica - 25mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
5 x  | PATIO
8 x  | TÉRREO
5 x  | PAV.01
4 x  | PAV. 02

# IfcSanitaryTerminal: Lavatório com Te de 90º (20)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com Te de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com Te de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com Te de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Tê red.90 sold c/ bucha latão B central - 25 mm -1/2": 1
Name | In
6 x  | PATIO
4 x  | TÉRREO
4 x  | PAV.01
6 x  | PAV. 02

# IfcSanitaryTerminal: Lavatório com joelho de 90º (12)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
 | PATIO
7 x  | TÉRREO
3 x  | PAV.01
 | PAV. 02

# IfcSanitaryTerminal: Lavatório de Uso Geral (96)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lavatório de Uso Geral; Nome: 40mm; Classe: PVC Esgoto; Tipo: Lavatório de Uso Geral; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório de Uso Geral
Name | In
7 x  | PATIO | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
14 x  | PATIO
10 x  | TÉRREO | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
20 x  | TÉRREO
14 x  | PAV.01
7 x  | PAV.01 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
8 x  | PAV. 02 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
16 x  | PAV. 02

# IfcSanitaryTerminal: Mictório c/sifão, c/válvula de descarga, com joelho de 90º (8)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.5; Indicação: MIC; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Mictório c/sifão,c/válvula de descarga,com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Mictório c/sifão, c/válvula de descarga, com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Mictório c/sifão, c/válvula de descarga, com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Mictório de Descarga Descontínua - 1/2": 1; Metais Pressmatic - Pressmatic mictório cromado - 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
2 x  | PATIO
2 x  | TÉRREO
2 x  | PAV.01
2 x  | PAV. 02

# IfcSanitaryTerminal: Mictório de Descarga Automática- DN 40mm (24)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Mictório de Descarga Automática- DN 40mm; Nome: 40mm; Classe: PVC Esgoto; Tipo: Mictório de Descarga Automática- DN 40mm; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Mictório de Descarga Automática- DN 40mm
Name | In
4 x  | PATIO
2 x  | PATIO | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível p/ Mictório - 1.1/4"- 2": 1; PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
2 x  | TÉRREO | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível p/ Mictório - 1.1/4"- 2": 1; PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
4 x  | TÉRREO
4 x  | PAV.01
2 x  | PAV.01 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível p/ Mictório - 1.1/4"- 2": 1; PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
4 x  | PAV. 02
2 x  | PAV. 02 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível p/ Mictório - 1.1/4"- 2": 1; PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Máquina de Lavar Roupas DN 50mm (3)
In: PATIO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Máquina de Lavar Roupas DN 50mm; Nome: 50mm; Classe: PVC Esgoto; Tipo: Máquina de Lavar Roupas DN 50mm; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Máquina de Lavar Roupas DN 50mm
Name
2 x 
 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 90 cm

# IfcSanitaryTerminal: Máquina de lavar roupa com joelho de 90º
In: PATIO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.3; Indicação: MLR; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Máquina de lavar roupa com joelho de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Máquina de lavar roupa com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Máquina de lavar roupa com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Máquina de Lavar Roupa - 25mm x 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Pia Industrial - 75mm (12)
In: PATIO
Type - PredefinedType: SINK
AltoQi_Builder - Indicação: 75mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Pia Industrial - 75mm com Sifão; Nome: 75mm; Classe: PVC Esgoto; Tipo: Pia Industrial - 75mm; Rede: Esgoto (Gordura)
Pset_SanitaryTerminalTypeCommon - Reference: Pia Industrial - 75mm
Name
8 x 
4 x  | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 2": 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Joelho 90 - 50 mm: 1; PVC Esgoto - Redução excêntrica - 75 mm - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 60 cm

# IfcSanitaryTerminal: Pia de Cozinha Residencial (3)
In: TÉRREO
Type - PredefinedType: SINK
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Pia de Cozinha Residencial com Sifão 50mm; Nome: 50mm; Classe: PVC Esgoto; Tipo: Pia de Cozinha Residencial; Rede: Esgoto (Gordura)
Pset_SanitaryTerminalTypeCommon - Reference: Pia de Cozinha Residencial
Name
 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 2": 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm
2 x 

# IfcSanitaryTerminal: Pia de cozinha com joelho de 90º (5)
Type - PredefinedType: SINK
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: PIA; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Pia de cozinha com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Pia de cozinha com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Pia de Cozinha - 25 mm - 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
4 x  | PATIO
 | TÉRREO

# IfcSanitaryTerminal: Tanque de Lavar Roupas DN 40mm (9)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm - QB; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Tanque de Lavar Roupas DN 40mm; Nome: 40mm; Classe: PVC Esgoto; Tipo: Tanque de Lavar Roupas DN 40mm; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de Lavar Roupas DN 40mm
Name | In
2 x  | PATIO
 | PATIO | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível c/ Adaptador - 1.1/2" - 1.1/2": 1; PVC Acessórios - Válvula p/ tanque - 1 1/2": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
 | TÉRREO | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível c/ Adaptador - 1.1/2" - 1.1/2": 1; PVC Acessórios - Válvula p/ tanque - 1 1/2": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
2 x  | TÉRREO
 | PAV.01 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível c/ Adaptador - 1.1/2" - 1.1/2": 1; PVC Acessórios - Válvula p/ tanque - 1 1/2": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
2 x  | PAV.01

# IfcSanitaryTerminal: Tanque de lavar com Te de 90º (2)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: TLR; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Tanque de lavar com Te de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Tanque de lavar com Te de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de lavar com Te de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Tanque de Lavar - 25mmx 3/4": 1; PVC soldável azul c/ bucha latão - Tê sold c/ bucha latão bolsa central - 25 mm- 3/4": 1
Name | In
 | PAV.01
 | PAV. 02

# IfcSanitaryTerminal: Tanque de lavar com joelho de 90º
In: PATIO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: TLR; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Tanque de lavar com joelho de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Tanque de lavar com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de lavar com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Tanque de Lavar - 25mmx 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Torneira de Jardim com Tê 90°
In: PATIO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: TJ; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Torneira de jardim com tê 90°; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com Tê 90°; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Torneira de Jardim com Tê 90°
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Jardim - 25 mm x 1/2": 1; PVC soldável azul c/ bucha latão - Tê red.90 sold c/ bucha latão B central - 25 mm -1/2": 1

# IfcSanitaryTerminal: Torneira de Jardim com joelho 90° (3)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: TJ; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Torneira de Jardim; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com joelho 90°; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Torneira de Jardim com joelho 90°
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Jardim - 25 mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
2 x  | PATIO
 | PAV. 02

# IfcSanitaryTerminal: Vaso Sanitário c/ J90º (40)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ J90º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ J90º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ J90º
Name | In
5 x  | PATIO | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
5 x  | PATIO
7 x  | TÉRREO | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
7 x  | TÉRREO
4 x  | PAV.01 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
4 x  | PAV.01
4 x  | PAV. 02
4 x  | PAV. 02 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1

# IfcSanitaryTerminal: Vaso Sanitário c/ junção e curva 45º (4)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ junção e curva 45º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ junção e curva 45º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ junção e curva 45º
Name | In
 | TÉRREO | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3; PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
 | TÉRREO
 | PAV.01 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3; PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
 | PAV.01

# IfcSanitaryTerminal: Vaso Sanitário com válvula de descarga (22)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Vazão de projeto (l/s): 1.7; Indicação: VS; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Vaso Sanitário com válvula de descarga; Nome: 1 1/2"; Classe: PVC rígido soldável; Tipo: Vaso Sanitário com válvula de descarga; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário com válvula de descarga
AltoQi_QiBuilder-Itens_Associados - Aparelho - Vaso Sanitário p/ Válvula de Descarga de 1 1/2" - 40mm - 1 1/2": 1
Name | In
5 x  | PATIO
8 x  | TÉRREO
5 x  | PAV.01
4 x  | PAV. 02

# IfcStackTerminal: Terminal de ventilação- coluna (4)
In: COBERTURA 01
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Terminal de ventilação- coluna; Rede: Ventilação
Name | Indicação = Nome | Descrição | PVC Esgoto - Terminal de ventilação - 50 mm
2 x  | 50 mm | Terminal de ventilação- coluna | 1
CV-13 | 50 mm | Terminal de ventilação- coluna | 1
CV-4 | 75 mm | Terminal de ventilação - coluna | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 75 mm: 1

# IfcTank: Tanque (3)
In: COBERTURA 01
Type - PredefinedType: STORAGE
AltoQi_Builder - Volume efetivo (l): 15000; Altura: 220 cm; Diâmetro: 320 cm; Indicação: 15000L; Posição: Direta; % do volume do reservatório: 33.33; Localização: Superior; Volume da RTI (m³): 5; Volume da edificação (m³/dia): 0.22; Volume útil estimado (m³): 5.08; Volume (m³): 15
Identificação_Elemento - Aplicação: Reservatório cilíndrico; Descrição: Reservatório 15000L; Nome: 15000L; Classe: Reservatório cilíndrico; Tipo: Tanque; Rede: Água fria
Pset_TankTypeCommon - Reference: Tanque; NominalCapacity: 15; NominalDepht: 220 cm; NominalLenghtOrDiameter: 320 cm
AltoQi_QiBuilder-Itens_Associados - Reservatório cilíndrico - Tanque - 15000 L: 1
Name
RCi1
RCi2
RCi3

# IfcValve: Registro bruto gaveta ABNT c/PVC soldável
In: PAV. 02
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto gaveta ABNT c/PVC soldável; Nome: 2"; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta ABNT c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro bruto gaveta ABNT c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta bruto ABNT - 2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 60 mm - 2": 2

# IfcValve: Registro bruto gaveta Industrial c/PVC soldável (3)
In: COBERTURA 01
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto gaveta Industrial c/PVC soldável; Nome: 3"; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta Industrial c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro bruto gaveta Industrial c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 3": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 85 mm - 3": 2

# IfcValve: Registro de gaveta c/canopla cromada c/PVC soldável (45)
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de gaveta c/canopla cromada c/PVC soldável; Classe: PVC rígido soldável; Tipo: Registro de gaveta c/canopla cromada c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de gaveta c/canopla cromada c/PVC soldável
Name | In | Nome | Metais - Registro de gaveta c/ canopla cromada - 3/4" | PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4"
7 x  | PATIO | 3/4" | 1 | 2
