Properties of the parts of a building model (IFC4), part 2 of 6

# IfcPipeFitting: Te de redução 90 soldável c/ redução lateral (26)
Name | In | Indicação = Nome | Rede
 | PATIO | 40 mm - 32 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 40 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 32 mm: 1
3 x  | TÉRREO | 32 mm - 25 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
 | TÉRREO | 40 mm - 32 mm- 25mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 40 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 32 mm: 1
 | TÉRREO | 60 mm - 50 mm- 50mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1
 | TÉRREO | 40 mm - 32 mm- 32mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 32 mm: 1; PVC rígido soldável - Bucha de redução sold. curta - 40 mm - 32 mm: 1
 | TÉRREO | 50 mm - 32 mm- 32mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 32 mm: 1
AF-1 | TÉRREO | 75 mm - 50 mm- 50mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 75 mm - 50 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 50 mm: 1
AF-2 | TÉRREO | 75 mm - 60 mm- 60mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 75 mm - 60 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 60 mm: 1
2 x  | PAV.01 | 32 mm - 25 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
 | PAV.01 | 40 mm - 32 mm- 32mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 32 mm: 1; PVC rígido soldável - Bucha de redução sold. curta - 40 mm - 32 mm: 1
 | PAV.01 | 60 mm - 50 mm- 50mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1
 | PAV.01 | 50 mm - 32 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 32 mm: 1; PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1
2 x  | PAV. 02 | 50 mm - 32 mm- 40mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 50 mm - 40 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 32 mm: 1
2 x  | PAV. 02 | 40 mm - 32 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 40 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 32 mm: 1
3 x  | PAV. 02 | 32 mm - 25 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
 | PAV. 02 | 60 mm - 50 mm- 50mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1

# IfcPipeFitting: Te sanitário (3)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm -50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário; Nome: 50 mm -50 mm; Classe: PVC Esgoto; Tipo: Te sanitário; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Te sanitário
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
Name | In
2 x  | TÉRREO
 | PAV.01

# IfcPipeFitting: Te sanitário- coluna (8)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário- coluna; Classe: PVC Esgoto; Tipo: Te sanitário- coluna
Pset_PipeFittingTypeCommon - Reference: Te sanitário- coluna
Name | In | Indicação = Nome | Rede
CV-7 | TÉRREO | 50 mm -50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
TQ-2 | TÉRREO | 100 mm - 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1
TQ-4 | TÉRREO | 100 mm - 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1
CV-7 | PAV.01 | 50 mm -50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
TQ-5 | PAV.01 | 75 mm - 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Tê sanitário - 75 mm - 75 mm: 1
TQ-6 | PAV.01 | 100 mm - 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1
AP-6 | PAV. 02 | 100 mm - 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 100 mm - 75 mm: 1
CV-7 | PAV. 02 | 50 mm -50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1

# IfcPipeFitting: Te sanitário- superior (5)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário- superior; Classe: PVC Esgoto; Tipo: Te sanitário- superior
Pset_PipeFittingTypeCommon - Reference: Te sanitário- superior
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Tê sanitário - 50 mm - 50 mm
 | TÉRREO | 100 mm - 50 mm | Esgoto | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
CV-5 | TÉRREO | 75 mm - 50 mm | Ventilação | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
CV-6 | TÉRREO | 50 mm -50 mm | Ventilação | 2 | 1
 | PAV. 02 | 50 mm -50 mm | Ventilação | 2 | 1
CV-9 | PAV. 02 | 50 mm -50 mm | Ventilação | 2 | 1

# IfcPipeSegment: Tubo rígido c/ ponta lisa (240)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 600 cm
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PATIO | 7.21 | ø3" | 0.17 | ø75 | 2 | 173.12 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 173.12 cm
 | PATIO | 9.8 | ø4" | 0.18 | ø100 | 1 | 21.1 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 21.0977 cm
 | PATIO | 14.5 | ø6" | 0.25 | ø150 | 1 | 848.22 | 150 mm- 6" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 848.222 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 195.41 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 195.407 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 34.92 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 34.9185 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 19.11 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 19.1095 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 18.5 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.5027 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 154.24 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 154.243 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 26.97 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 26.9745 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 17.04 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.0441 cm
2 x  | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 16.18 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 16.1825 cm
2 x  | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 44.14 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 44.1433 cm
2 x  | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 47.28 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 47.2833 cm
2 x  | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 30.03 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 30.0253 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.5 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.5 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.97 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.9653 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 45.88 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.878 cm
 | PATIO | 7.21 | ø3" | 0.17 | ø75 | 2 | 19.72 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 19.7248 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.95 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.9456 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 11.08 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 11.0809 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.95 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.9452 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 12.2 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.1976 cm
 | PATIO | 7.21 | ø3" | 0.17 | ø75 | 2 | 19.36 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 19.3561 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 167.96 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 167.963 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 22.6 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 22.5956 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 27.86 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.8561 cm
 | PATIO | 9.8 | ø4" | 0.18 | ø100 | 1 | 6.65 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.64798 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 10.34 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.3431 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 8.45 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.44814 cm
 | PATIO | 7.21 | ø3" | 0.17 | ø75 | 2 | 93.29 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 93.2925 cm
 | PATIO | 9.8 | ø4" | 0.18 | ø100 | 2 | 2.81 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2.808 cm
 | PATIO | 9.8 | ø4" | 0.18 | ø100 | 1 | 11.61 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.6051 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.51 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.50837 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | -0.79 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.11 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.1059 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.59 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.58683 cm
2 x  | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 12.78 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.7777 cm
2 x  | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 50.16 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 50.1574 cm
2 x  | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 44.72 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 44.7211 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 34.53 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 34.5323 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 19.3 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 19.3022 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 162.68 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 162.683 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 48.02 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 48.0213 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 30.2 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 30.2022 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 1 | 50.61 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.6054 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 18.45 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.4481 cm
 | PATIO | 9.8 | ø4" | 0.18 | ø100 | 1 | 203.83 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 203.833 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 197.54 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 197.537 cm
 | PATIO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 123.09 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 123.089 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 38.23 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 38.2267 cm
 | PATIO | 7.21 | ø3" | 0.17 | ø75 | 2 | 46 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 46.0008 cm
 | PATIO | 7.21 | ø3" | 0.17 | ø75 | 2 | -8.73 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -8.73446 cm
 | PATIO | 4.75 | ø2" | 0.16 | ø50 | 2 | 36.9 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 36.9 cm
 | PATIO | 14.5 | ø6" | 0.25 | ø150 | 1 | 450.45 | 150 mm- 6" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 450.451 cm
 | PATIO | 14.5 | ø6" | 0.25 | ø150 | 1 | 57.39 | 150 mm- 6" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 57.3884 cm
 | PATIO | 14.5 | ø6" | 0.25 | ø150 | 1 | 379.36 | 150 mm- 6" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 379.356 cm
 | PATIO | 19.5 | ø8" | 0.25 | ø200 | 1 | 1333.03 | 200 mm- 8" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 1333.03 cm
 | PATIO | 19.5 | ø8" | 0.25 | ø200 | 1 | 898.51 | 200 mm- 8" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 898.507 cm
 | PATIO | 14.5 | ø6" | 0.25 | ø150 | 1 | 971.33 | 150 mm- 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 971.334 cm
 | PATIO | 19.5 | ø8" | 0.25 | ø200 | 1 | 1091.28 | 200 mm- 8" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 1091.28 cm
 | PATIO | 19.5 | ø8" | 0.25 | ø200 | 1 | 74.63 | 200 mm- 8" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 74.6346 cm
 | PATIO | 14.5 | ø6" | 0.25 | ø150 | 1 | 641.42 | 150 mm- 6" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 641.424 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 16.17 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 16.1706 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 65.17 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 65.1669 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 19.62 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 19.6182 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 139.36 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 139.36 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 181.53 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 181.527 cm
 | TÉRREO | 9.8 | ø4" | 0.18 | ø100 | 1 | 22.52 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 22.5226 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.42 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.4179 cm
4 x  | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 47.28 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 47.2833 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 46.73 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 46.7325 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 46.72 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 46.7209 cm
2 x  | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.5 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.5 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 15.61 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.6103 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 118.98 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 118.983 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 112.56 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 112.564 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.06 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.05946 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 29.99 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 29.9928 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 30.06 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 30.0578 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.97 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.9714 cm
2 x  | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.16 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.1623 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 11.63 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 11.6348 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 12.12 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.1209 cm
 | TÉRREO | 7.21 | ø3" | 0.17 | ø75 | 2 | 10.26 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 10.2578 cm
 | TÉRREO | 7.21 | ø3" | 0.17 | ø75 | 2 | -5.39 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -5.39321 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 5.84 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.84036 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 20.23 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 20.2294 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.58 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.5788 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 27.95 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.9534 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 30.07 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 30.0722 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 16.49 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.4857 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 14.01 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.0067 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 1.06 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 1.05946 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 18.89 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.8914 cm
2 x  | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 32.81 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 32.8129 cm
2 x  | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 122.09 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 122.086 cm
2 x  | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 7.6 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 7.60011 cm
2 x  | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.87 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.872 cm
2 x  | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 6.74 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.74203 cm
2 x  | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 9.63 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.62539 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 127.39 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 127.388 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 14.29 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 14.2939 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.89 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.89459 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | -0.38 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 15.52 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.5185 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 41.43 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 41.4258 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.36 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.3629 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 8.18 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.17515 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 294.01 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 294.006 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 293.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 293.8 cm
 | TÉRREO | 7.21 | ø3" | 0.17 | ø75 | 1 | 1.17 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 1.16955 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 155.45 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 155.454 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 22.49 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 22.4936 cm
 | TÉRREO | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 15.82 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 15.8184 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 10.83 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.8298 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2 | 5.75 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.74891 cm
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 1 | 369.54 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 369.545 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.61 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.611 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 16.17 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 16.1706 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 65.17 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 65.1669 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 13.9 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 13.8982 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 50.36 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.3578 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 6.9 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.89593 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 128.23 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 128.23 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 12.73 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.731 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 91.23 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 91.2268 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 19.62 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 19.6182 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 135.19 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 135.188 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 6.57 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.57343 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 2.28 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 2.28416 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 0.78 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 9.86 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.8626 cm
 | PAV.01 | 9.8 | ø4" | 0.18 | ø100 | 1 | 22.52 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 22.5226 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.42 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.4179 cm
4 x  | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 47.28 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 47.2833 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 46.73 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 46.7325 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 46.72 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 46.7209 cm
2 x  | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.5 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.5 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 15.61 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.6103 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 118.98 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 118.983 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 112.56 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 112.564 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.06 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.05946 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 29.99 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 29.9928 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 30.06 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 30.0578 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.97 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.9714 cm
2 x  | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.16 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.1623 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 11.63 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 11.6348 cm
 | PAV.01 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 12.12 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.1209 cm
 | PAV.01 | 7.21 | ø3" | 0.17 | ø75 | 2 | 10.26 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 10.2578 cm
 | PAV.01 | 7.21 | ø3" | 0.17 | ø75 | 2 | -5.39 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -5.39321 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 10.44 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.4404 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 20.23 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 20.2294 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.58 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.5788 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 30.07 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 30.0722 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 16.49 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.4857 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 14.01 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.0067 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 1.06 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 1.05946 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 18.89 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.8914 cm
 | PAV.01 | 4.75 | ø2" | 0.16 | ø50 | 2 | 340.1 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 340.1 cm
 | PAV. 02 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2.51 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2.50737 cm
 | PAV. 02 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.98 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.97608 cm
 | PAV. 02 | 9.8 | ø4" | 0.18 | ø100 | 1 | 19.81 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 19.8054 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.02 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.0187 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 13.04 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 13.0449 cm
3 x  | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 47.28 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 47.2833 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 35.7 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 35.7 cm
2 x  | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.5 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.5 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 35.91 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 35.9067 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | -0.18 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 167.71 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 167.708 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 10.99 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.9896 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.81 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.80884 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 4.15 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 4.1452 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 75.29 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 75.2883 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 0.13 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 270.31 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 270.315 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 47.36 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 47.3578 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 43.18 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 43.1773 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 43.32 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 43.3176 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 23.2 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 23.2039 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 179.25 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 179.251 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 43.4 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 43.4011 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.95 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.9456 cm
2 x  | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 8.13 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 8.13052 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 26.95 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.9452 cm
 | PAV. 02 | 7.21 | ø3" | 0.17 | ø75 | 2 | 16.21 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 16.2056 cm
 | PAV. 02 | 7.21 | ø3" | 0.17 | ø75 | 2 | -0.17 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
2 x  | PAV. 02 | 7.21 | ø3" | 0.17 | ø75 | 2 | -0.8 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. 02 | 7.21 | ø3" | 0.17 | ø75 | 2 | -0.13 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 16.17 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 16.1706 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 65.17 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 65.1669 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.01 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.0066 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 128.03 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 128.03 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 13.9 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 13.8982 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 12.73 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.731 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 91.23 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 91.2268 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.14 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.14365 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 50.71 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.7082 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 0.38 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 2 | 6.57 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.57343 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 19.62 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 19.6182 cm
 | PAV. 02 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 135.19 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 135.188 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 16.15 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.146 cm
 | PAV. 02 | 4.75 | ø2" | 0.16 | ø50 | 1 | 3.45 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 3.45415 cm
 | COBERTURA 01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 6.55 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.55162 cm
2 x  | COBERTURA 01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 5.61 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.61471 cm
 | COBERTURA 01 | 4.75 | ø2" | 0.16 | ø50 | 1 | 286.9 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 286.9 cm
 | COBERTURA 02 | 7.21 | ø3" | 0.17 | ø75 | 1 | 35.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 35.6 cm
 | COBERTURA 02 | 9.8 | ø4" | 0.18 | ø100 | 1 | 391.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 391.1 cm
 | COBERTURA 02 | 9.8 | ø4" | 0.18 | ø100 | 1 | 371.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 371.1 cm
 | COBERTURA 02 | 7.21 | ø3" | 0.17 | ø75 | 1 | 343.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 343.6 cm

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (405)
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa e luva simples
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 109.32 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 109.319 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 26.06 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 26.0597 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.03 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.02898 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 155.24 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 155.241 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | -0.92 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 21.72 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 21.7194 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 9.6 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 9.6 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 156.04 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 156.044 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 39.9 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 39.9025 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 23.53 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 23.5308 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 17.19 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.1939 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 41.69 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 41.6872 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 132.65 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 132.646 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 129.45 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 129.453 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 158.72 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 158.72 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 173.14 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 173.143 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 74.09 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 74.0879 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 13.88 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 13.8756 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 25.34 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 25.3375 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 23.88 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 23.8817 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 39.3 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 39.302 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 136.14 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 136.143 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 236.93 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 236.925 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 28.39 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 28.3911 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 180.44 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 180.442 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | -2.96 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": -2.9597 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 242.64 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 242.644 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 46.95 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 46.9529 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 221.09 | 75 mm - 3" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 221.088 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 10.24 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 10.2372 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 10.53 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.5328 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 37.25 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 37.2455 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 18.64 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.6433 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 19.96 | 100 mm - 4" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 19.9586 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 35.51 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.5106 cm
3 x  | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 36.9 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 36.9 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 405.59 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 405.591 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 32.6 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 32.6002 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 237.45 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 237.449 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 63.11 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 63.1096 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | -2.76 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -2.76342 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 112.1 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 112.095 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 4.73 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 4.72652 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 108.93 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 108.926 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 10.19 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.1868 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 37.12 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 37.1224 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 11.36 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.3553 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 17.59 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.5922 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.93 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.93145 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 27.02 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 27.0206 cm
2 x  | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 19.56 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 19.5553 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 37.81 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 37.808 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 16.6 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 16.5987 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 3.64 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 3.64292 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 41.35 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 41.352 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 174.99 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 174.991 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 67.18 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 67.1827 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 22.21 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 22.2135 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 35.64 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 35.6366 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 3.92 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 3.92236 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 62.35 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 62.3514 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 76.71 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 76.7061 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 136.93 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 136.933 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.95 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.9472 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 1.46 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 1.4571 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 47.46 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 47.4605 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 25.89 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 25.8873 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 68.25 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 68.2456 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 9.23 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.22563 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 35.69 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.687 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 6.68 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.68028 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 192.35 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 192.355 cm
