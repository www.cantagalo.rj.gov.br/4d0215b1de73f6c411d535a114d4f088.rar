Properties of the parts of a building model (IFC4), part 1 of 6

# File
Description: IFC4
Time: 2026-06-03T10:57:30
Made in: IfcPlusPlus

# IfcBuildingStorey (6)
Name | LongName | Elevation (cm)
PATIO | PATIO | 0
TÉRREO | TÉRREO | 300
PAV.01 | PAV.01 | 646
PAV. 02 | PAV. 02 | 996
COBERTURA 01 | COBERTURA 01 | 1350
COBERTURA 02 | COBERTURA 02 | 1707

# IfcFlowMeter: Alimentador Predial
In: TÉRREO
Type - PredefinedType: WATERMETER
AltoQi_Builder - Indicação: Com tubo de PVC rígido-3/4"; Posição: Direta
Identificação_Elemento - Aplicação: Alimentador predial; Descrição: Alimentador Predial; Nome: Com tubo de PVC rígido-3/4"; Classe: PVC rígido soldável; Tipo: Alimentador Predial; Rede: Alimentação
Pset_FlowMeterTypeCommon - Reference: Alimentador Predial
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de esfera - 3/4": 1; PVC misto soldável - Colar de tomada em PVC - 3/4": 1; PVC misto soldável - Joelho 90 soldável c/ rosca - 25 mm - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 1

# IfcInterceptor: Caixa de gordura, Caixa de gordura -1
In: PATIO
Type - PredefinedType: OIL
AltoQi_Builder - Indicação: CGD; Posição: Direta; Altura sobressalente: 25 cm; Número de cozinhas: Uma cozinha; Tipo de caixa: Pequena (CGP); Volume estimado de retenção (l): 18; Diâmetro: 30 cm; Profundidade útil: 30 cm; Volume de retenção (l): 18.4
Identificação_Elemento - Aplicação: Caixa de gordura; Descrição: CGD; Nome: Concreto; Classe: Unidades de tratamento; Tipo: Caixa de gordura; Rede: Esgoto (Gordura)
Pset_InterceptorTypeCommon - Reference: Caixa de gordura
AltoQi_QiBuilder-Itens_Associados - Unidades de tratamento - Alça - Ferro: 1; Unidades de tratamento - Concreto - Concreto: 0.0721 m3

# IfcInterceptor: Caixas de Gordura (2)
In: PATIO
Type - PredefinedType: OIL
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Caixa de passagem; Descrição: Caixas de Gordura; Classe: Caixas de Passagem; Tipo: Caixas de Gordura; Rede: Esgoto
Pset_InterceptorTypeCommon - Reference: Caixas de Gordura
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de gordura PVC - CG 30 cm: 1
Name | Indicação = Nome
 | CG PVC- DN 30 cm | AltoQi_Builder - Diâmetro: 30 cm
 | CG PVC- 30x30 cm | AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm

# IfcPipeFitting: Adapt sold. c/ flange livre p/ cx. d´água
In: COBERTURA 01
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 85 mm - 3"; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Adapt sold. c/ flange livre p/ cx. d´água; Nome: 85 mm - 3"; Classe: PVC rígido soldável; Tipo: Adapt sold. c/ flange livre p/ cx. d´água; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Adapt sold. c/ flange livre p/ cx. d´água
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Adapt sold. c/ flange livre p/ cx. d´água - 85 mm - 3": 1

# IfcPipeFitting: Cap soldável (6)
Type - PredefinedType: EXIT
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cap soldável; Classe: PVC rígido soldável; Tipo: Cap soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Cap soldável
Name | In | Indicação = Nome
 | PATIO | 60 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Cap soldável - 60 mm: 1
 | TÉRREO | 60 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Cap soldável - 60 mm: 1
 | TÉRREO | 32 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Cap soldável - 32 mm: 1
2 x  | COBERTURA 01 | 85 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Cap soldável - 85 mm: 1
 | COBERTURA 01 | 60 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Cap soldável - 60 mm: 1

# IfcPipeFitting: Curva 45 soldável
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Curva 45 soldável; Rede: Água fria (Reúso)
Pset_PipeFittingTypeCommon - Reference: Curva 45 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 45 soldável - 25 mm: 1

# IfcPipeFitting: Curva 45º curta Amanco
In: PAV.01
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45º curta Amanco; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 45º curta Amanco; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 45º curta Amanco
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 45 curta Amanco - 100 mm: 1

# IfcPipeFitting: Curva 90 curta (33)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta; Classe: PVC Esgoto; Tipo: Curva 90 curta
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta
Name | In | Indicação = Nome | Rede
6 x  | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
 | PATIO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 90 curta - 50 mm: 1
 | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
 | PATIO | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Curva 90 curta - 75 mm: 1
2 x  | PATIO | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Curva 90 curta - 75 mm: 1
 | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 90 curta - 50 mm: 1
2 x  | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
 | TÉRREO | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Curva 90 curta - 75 mm: 1
 | PAV.01 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Curva 90 curta - 75 mm: 1
3 x  | PAV.01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 90 curta - 50 mm: 1
 | PAV.01 | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 90 curta - 50 mm: 1
 | PAV.01 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 90 curta - 50 mm: 1
 | PAV. 02 | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 90 curta - 50 mm: 1
5 x  | PAV. 02 | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Curva 90 curta - 75 mm: 1
 | PAV. 02 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
 | PAV. 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Curva 90 curta - 75 mm: 1
3 x  | COBERTURA 01 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1

# IfcPipeFitting: Curva 90 longa
In: COBERTURA 02
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 longa; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 90 longa; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Curva 90 longa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 longa - 100 mm: 1

# IfcPipeFitting: Curva de transposição (15)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: CT; Posição: Direta
Identificação_Elemento - Aplicação: Curva de transposição; Descrição: Curva de transposição; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Curva de transposição; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Curva de transposição
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva de transposição - 25 mm: 1
Name | In
4 x  | PATIO
4 x  | TÉRREO
4 x  | PAV.01
3 x  | PAV. 02

# IfcPipeFitting: Joelho 45 (158)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Classe: PVC Esgoto; Tipo: Joelho 45
Pset_PipeFittingTypeCommon - Reference: Joelho 45
Name | In | Indicação = Nome | Rede
9 x  | PATIO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
9 x  | PATIO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
10 x  | PATIO | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
2 x  | PATIO | 50 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
7 x  | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
3 x  | PATIO | 75 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
2 x  | PATIO | 100 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
 | PATIO | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
4 x  | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
 | PATIO | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
8 x  | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
 | TÉRREO | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
7 x  | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
14 x  | TÉRREO | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
8 x  | TÉRREO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
 | TÉRREO | 50 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
3 x  | TÉRREO | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
4 x  | PAV.01 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
9 x  | PAV.01 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
7 x  | PAV.01 | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
11 x  | PAV.01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
2 x  | PAV.01 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
 | PAV.01 | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
10 x  | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
9 x  | PAV. 02 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
7 x  | PAV. 02 | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
2 x  | PAV. 02 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
3 x  | PAV. 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
3 x  | PAV. 02 | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1

# IfcPipeFitting: Joelho 45 soldável (32)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45 soldável; Classe: PVC rígido soldável; Tipo: Joelho 45 soldável
Pset_PipeFittingTypeCommon - Reference: Joelho 45 soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Joelho 45 soldável - 32 mm
2 x  | PATIO | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 25 mm: 1
8 x  | TÉRREO | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 25 mm: 1
3 x  | TÉRREO | 32 mm | Água fria (Reúso) | 1
2 x  | TÉRREO | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 40 mm: 1
13 x  | PAV.01 | 32 mm | Água fria (Reúso) | 1
 | PAV.01 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 25 mm: 1
3 x  | PAV. 02 | 32 mm | Água fria (Reúso) | 1

# IfcPipeFitting: Joelho 90 (2)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90; Classe: PVC Esgoto; Tipo: Joelho 90
Pset_PipeFittingTypeCommon - Reference: Joelho 90
Name | In | Indicação = Nome | Rede
 | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1

# IfcPipeFitting: Joelho 90 c/ visita (3)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm - 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90 c/ visita; Nome: 100 mm - 50 mm; Classe: PVC Esgoto; Tipo: Joelho 90 c/ visita; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Joelho 90 c/ visita
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 c/ visita - 100 mm - 50 mm: 1
Name | In
2 x  | TÉRREO
 | PAV.01

# IfcPipeFitting: Joelho 90 soldável (298)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90 soldável; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável
Pset_PipeFittingTypeCommon - Reference: Joelho 90 soldável
Name | In | Indicação = Nome | Rede
12 x  | PATIO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
5 x  | PATIO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
30 x  | PATIO | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
3 x  | PATIO | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
3 x  | PATIO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AF-2 | PATIO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AR-1 | PATIO | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 40 mm: 1
18 x  | TÉRREO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
2 x  | TÉRREO | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 40 mm: 1
39 x  | TÉRREO | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
11 x  | TÉRREO | 25 mm | Alimentação | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
4 x  | TÉRREO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
6 x  | TÉRREO | 25 mm | Água fria (Reúso) | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
12 x  | TÉRREO | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
 | TÉRREO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AL-1 | TÉRREO | 25 mm | Alimentação | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
14 x  | PAV.01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
10 x  | PAV.01 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
3 x  | PAV.01 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
20 x  | PAV.01 | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
3 x  | PAV.01 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
 | PAV.01 | 25 mm | Água fria (Reúso) | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
AR-1 | PAV.01 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 40 mm: 1
13 x  | PAV. 02 | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
7 x  | PAV. 02 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
8 x  | PAV. 02 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
11 x  | PAV. 02 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
4 x  | PAV. 02 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 40 mm: 1
4 x  | PAV. 02 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AF-6 | PAV. 02 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
4 x  | COBERTURA 01 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
2 x  | COBERTURA 01 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 75 mm: 1
17 x  | COBERTURA 01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
5 x  | COBERTURA 01 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 85 mm: 1
10 x  | COBERTURA 01 | 25 mm | Alimentação | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
 | COBERTURA 01 | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
AF-1 | COBERTURA 01 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 75 mm: 1
AF-2 | COBERTURA 01 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 75 mm: 1
AF-3 | COBERTURA 01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-4 | COBERTURA 01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-5 | COBERTURA 01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-6 | COBERTURA 01 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AF-7 | COBERTURA 01 | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
AF-8 | COBERTURA 01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-9 | COBERTURA 01 | 25 mm | Água fria | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
AL-1 | COBERTURA 01 | 25 mm | Alimentação | Grupo - Fabricante: Teste; Preço: 12; AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1

# IfcPipeFitting: Joelho 90- coluna (51)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna; Classe: PVC Esgoto; Tipo: Joelho 90- coluna
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna
Name | In | Indicação = Nome | Rede
3 x  | PATIO | 50 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
 | PATIO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-1 | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-2 | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-3 | PATIO | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
AP-4 | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-5 | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-6 | PATIO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
CV-1 | PATIO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-2 | PATIO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-3 | PATIO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TG-1 | PATIO | 50 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TQ-1 | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
TQ-2 | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
TQ-3 | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
TQ-4 | PATIO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-7 | TÉRREO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-8 | TÉRREO | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
CV-4 | TÉRREO | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
CV-8 | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-9 | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TQ-5 | TÉRREO | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
TQ-6 | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
 | PAV.01 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
AP-9 | PAV.01 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
CV-10 | PAV.01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-4 | PAV.01 | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
CV-9 | PAV.01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
2 x  | PAV. 02 | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
5 x  | PAV. 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
AP-10 | PAV. 02 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-11 | PAV. 02 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
CV-11 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-12 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-13 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
3 x  | COBERTURA 01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-13 | COBERTURA 01 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
AP-14 | COBERTURA 01 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-15 | COBERTURA 01 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
 | COBERTURA 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
 | COBERTURA 02 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1

# IfcPipeFitting: Joelho 90- desce (24)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- desce; Classe: PVC Esgoto; Tipo: Joelho 90- desce
Pset_PipeFittingTypeCommon - Reference: Joelho 90- desce
Name | In | Indicação = Nome | Rede
2 x  | TÉRREO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-2 | TÉRREO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-3 | TÉRREO | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
CV-2 | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-3 | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TG-1 | TÉRREO | 50 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TQ-3 | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-4 | PAV.01 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
CV-6 | PAV.01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-8 | PAV.01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TQ-2 | PAV.01 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
 | PAV. 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
AP-1 | PAV. 02 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
CV-10 | PAV. 02 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
TQ-1 | PAV. 02 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
TQ-5 | PAV. 02 | 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
TQ-6 | PAV. 02 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-12 | COBERTURA 01 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-8 | COBERTURA 01 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
CV-11 | COBERTURA 01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-12 | COBERTURA 01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
CV-7 | COBERTURA 01 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-13 | COBERTURA 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1

# IfcPipeFitting: Joelho de redução 90 soldável (2)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 32 mm - 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho de redução 90 soldável; Nome: 32 mm - 25 mm; Classe: PVC rígido soldável; Tipo: Joelho de redução 90 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Joelho de redução 90 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho de redução 90 soldável - 32 mm - 25 mm: 1
Name | In
 | PATIO
 | PAV. 02

# IfcPipeFitting: Junção simples (26)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 100mm - 4" | PVC Esgoto - Anel de borracha - 50mm - 2"
3 x  | PATIO | 100 mm - 50 mm | Esgoto | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
 | PATIO | 100 mm- 100 mm | Esgoto | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
 | PATIO | 50 mm - 50 mm | Ventilação |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
3 x  | TÉRREO | 50 mm - 50 mm | Ventilação |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
3 x  | TÉRREO | 100 mm - 50 mm | Esgoto | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
4 x  | TÉRREO | 100 mm- 100 mm | Esgoto | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
2 x  | PAV.01 | 100 mm - 50 mm | Esgoto | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
2 x  | PAV.01 | 100 mm- 100 mm | Esgoto | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
3 x  | PAV.01 | 50 mm - 50 mm | Ventilação |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
3 x  | PAV. 02 | 100 mm - 50 mm | Esgoto | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
 | PAV. 02 | 75 mm 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Junção simples - 75 mm 75 mm: 1

# IfcPipeFitting: Junção simples c/ J45 (39)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples c/ J45; Classe: PVC Esgoto; Tipo: Junção simples c/ J45
Pset_PipeFittingTypeCommon - Reference: Junção simples c/ J45
Name | In | Indicação | Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Joelho 45 - 50 mm | PVC Esgoto - Anel de borracha - 100mm - 4"
3 x  | PATIO | 50 mm - 50 mm | 50 mm - 50 mm | Ventilação | 3 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
3 x  | PATIO | 100 mm - 50 mm | 100 mm - 50 mm | Esgoto (Gordura) | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
2 x  | PATIO | 100 mm - 50 mm | 100 mm - 50 mm | Esgoto | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
3 x  | PATIO | 100 mm- 100 mm | 100 mm - 100 mm | Esgoto |  |  | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
2 x  | PATIO | 100 mm - 75 mm | 100 mm - 75 mm | Esgoto (Gordura) |  |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 100 mm - 75 mm: 1
 | PATIO | 100 mm- 100 mm | 100 mm - 100 mm | Esgoto (Gordura) |  |  | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
 | PATIO | 75 mm - 50 mm | 75 mm - 50 mm | Esgoto | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Junção simples - 75 mm - 50 mm: 1
 | PATIO | 50 mm - 50 mm | 50 mm - 50 mm | Esgoto | 3 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
3 x  | TÉRREO | 50 mm - 50 mm | 50 mm - 50 mm | Ventilação | 3 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
 | TÉRREO | 100 mm - 75 mm | 100 mm - 75 mm | Esgoto |  |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 100 mm - 75 mm: 1
 | TÉRREO | 75 mm 75 mm | 75 mm - 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 3; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 75 mm 75 mm: 1
3 x  | TÉRREO | 100 mm - 50 mm | 100 mm - 50 mm | Esgoto | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
 | PAV.01 | 75 mm 75 mm | 75 mm - 75 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 3; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 75 mm 75 mm: 1
 | PAV.01 | 100 mm - 50 mm | 100 mm - 50 mm | Esgoto | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
3 x  | PAV.01 | 50 mm - 50 mm | 50 mm - 50 mm | Ventilação | 3 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
 | PAV.01 | 100 mm - 75 mm | 100 mm - 75 mm | Esgoto |  |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 100 mm - 75 mm: 1
4 x  | PAV. 02 | 50 mm - 50 mm | 50 mm - 50 mm | Ventilação | 3 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
2 x  | PAV. 02 | 100 mm - 75 mm | 100 mm - 75 mm | Esgoto |  |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 100 mm - 75 mm: 1
2 x  | PAV. 02 | 100 mm- 100 mm | 100 mm - 100 mm | Esgoto |  |  | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
 | PAV. 02 | 75 mm 75 mm | 75 mm - 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 3; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 75 mm 75 mm: 1

# IfcPipeFitting: Junção simples c/ J45 - Coluna (4)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples c/ J45 - Coluna; Classe: PVC Esgoto; Tipo: Junção simples c/ J45 - Coluna; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Junção simples c/ J45 - Coluna
Name | In | Indicação | Nome | PVC Esgoto - Anel de borracha - 100mm - 4"
AP-1 | PAV.01 | 100 mm - 75 mm | 100 mm - 75 mm | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 100 mm - 75 mm: 1
AP-5 | PAV. 02 | 100 mm - 75 mm | 100 mm - 75 mm | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 100 mm - 75 mm: 1
 | COBERTURA 01 | 100 mm- 100 mm | 100 mm - 100 mm | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
AP-10 | COBERTURA 01 | 100 mm- 100 mm | 100 mm - 100 mm | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1

# IfcPipeFitting: Junção simples c/ J45 - Vertical (3)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 100 mm- 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples c/ J45 - Vertical; Nome: 100 mm - 100 mm; Classe: PVC Esgoto; Tipo: Junção simples c/ J45 - Vertical
Pset_PipeFittingTypeCommon - Reference: Junção simples c/ J45 - Vertical
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3; PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
Name | In | Rede
TQ-1 | TÉRREO | Esgoto
AP-9 | PAV. 02 | Pluvial
AP-6 | COBERTURA 02 | Pluvial

# IfcPipeFitting: Junção simples c/ redução (12)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples c/ redução; Classe: PVC Esgoto; Tipo: Junção simples c/ redução
Pset_PipeFittingTypeCommon - Reference: Junção simples c/ redução
Name | In | Indicação | Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Anel de borracha - 75mm - 3" | PVC Esgoto - Redução excêntrica - 75 mm - 50 mm
 | PATIO | 75 mm - 75 mm(75-50) | 75 mm - 75 mm(50-75) | Esgoto (Gordura) | 1 | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm 75 mm: 1
 | PATIO | 100 mm- 100 mm(50-100) | 100 mm- 100 mm(50-100) | Esgoto | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1; PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1
3 x  | PATIO | 75 mm - 75 mm(75-50) | 75 mm - 75 mm(50-75) | Esgoto | 1 | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm 75 mm: 1
 | TÉRREO | 75 mm - 50 mm(50-50) | 75 mm - 50 mm(50-50) | Ventilação | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1
 | PAV.01 | 75 mm - 50 mm(50-50) | 75 mm - 50 mm(50-50) | Esgoto | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1
 | PAV.01 | 75 mm - 50 mm(50-50) | 75 mm - 50 mm(50-50) | Ventilação | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1
 | PAV. 02 | 100 mm- 100 mm(50-100) | 100 mm- 100 mm(50-100) | Esgoto | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1; PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1
 | PAV. 02 | 75 mm - 50 mm(50-50) | 75 mm - 50 mm(50-50) | Esgoto | 2 | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1
 | PAV. 02 | 75 mm - 75 mm(75-50) | 75 mm - 75 mm(50-75) | Esgoto | 1 | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm 75 mm: 1
 | PAV. 02 | 100 mm- 100 mm(75-100) | 100 mm- 100 mm(75-100) | Esgoto |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1; PVC Esgoto - Redução excêntrica - 100 mm - 75 mm: 1

# IfcPipeFitting: Luva simples- coluna (15)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva simples- coluna; Classe: PVC Esgoto; Tipo: Luva simples- coluna
Pset_PipeFittingTypeCommon - Reference: Luva simples- coluna
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 100mm - 4" = PVC Esgoto - Luva simples - 100 mm
AP-1 | TÉRREO | 100 mm | Pluvial | 1
AP-4 | TÉRREO | 100 mm | Pluvial | 1
AP-5 | TÉRREO | 100 mm | Pluvial | 1
AP-6 | TÉRREO | 100 mm | Pluvial | 1
AP-5 | PAV.01 | 100 mm | Pluvial | 1
AP-6 | PAV.01 | 100 mm | Pluvial | 1
AP-7 | PAV.01 | 100 mm | Pluvial | 1
AP-8 | PAV.01 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Luva simples - 75 mm: 1
TQ-1 | PAV.01 | 100 mm | Esgoto | 1
AP-7 | PAV. 02 | 100 mm | Pluvial | 1
AP-8 | PAV. 02 | 75 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Luva simples - 75 mm: 1
CV-4 | PAV. 02 | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Luva simples - 75 mm: 1
AP-11 | COBERTURA 01 | 100 mm | Pluvial | 1
AP-5 | COBERTURA 01 | 100 mm | Pluvial | 1
AP-6 | COBERTURA 01 | 100 mm | Pluvial | 1

# IfcPipeFitting: Luva soldável (8)
In: PAV. 02
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva soldável; Classe: PVC rígido soldável; Tipo: Luva soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva soldável
Name | Indicação = Nome
AF-1 | 75 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 75 mm: 1
AF-2 | 75 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 75 mm: 1
AF-3 | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 50 mm: 1
AF-4 | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 50 mm: 1
AF-5 | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 50 mm: 1
AF-7 | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 25 mm: 1
AF-8 | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 50 mm: 1
AF-9 | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 25 mm: 1

# IfcPipeFitting: Ramais de Ventilação (42)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação
Pset_PipeFittingTypeCommon - Reference: Ramais de Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 50 mm: 1
Name | In | Indicação = Nome | Descrição | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Tê sanitário - 50 mm - 50 mm
5 x  | PATIO | 50mm-50mm-45º | Ramais de Ventilação | Ventilação | 3 | 1
 | PATIO | 50mm-50mm-90º | Ramais de Ventilação | Ventilação | 3 | 1
 | PATIO | 75mm- 50mm-90º | Ramais de Ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
 | PATIO | 50mm-50mm-135º | Ramais de Ventilação | Ventilação | 3 | 1
4 x  | TÉRREO | 50mm-50mm-45º | Ramais de Ventilação | Ventilação | 3 | 1
2 x  | TÉRREO | 100mm - 50mm-45° | Ramais de ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
 | TÉRREO | 100mm - 50mm-135° | Ramais de ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
 | TÉRREO | 75mm- 50mm-90º | Ramais de Ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
5 x  | TÉRREO | 50mm-50mm-90º | Ramais de Ventilação | Ventilação | 3 | 1
 | TÉRREO | 50mm-50mm-90º | Ramais de Ventilação | Esgoto | 3 | 1
7 x  | PAV.01 | 50mm-50mm-45º | Ramais de Ventilação | Ventilação | 3 | 1
2 x  | PAV.01 | 100mm - 50mm-45° | Ramais de ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
 | PAV.01 | 75mm- 50mm-90º | Ramais de Ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
 | PAV.01 | 100mm - 50mm-135° | Ramais de ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
4 x  | PAV. 02 | 50mm-50mm-45º | Ramais de Ventilação | Ventilação | 3 | 1
 | PAV. 02 | 50mm-50mm-45º | Ramais de Ventilação | Esgoto | 3 | 1
 | PAV. 02 | 75mm- 50mm-90º | Ramais de Ventilação | Esgoto | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
 | PAV. 02 | 75mm- 50mm-90º | Ramais de Ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
 | PAV. 02 | 75mm- 50mm-45º | Ramais de Ventilação | Ventilação | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
 | PAV. 02 | 50mm-50mm-90º | Ramais de Ventilação | Ventilação | 3 | 1

# IfcPipeFitting: Ramais de ventilação em cruz (5)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Descrição: Ramais de Ventilação em Cruz; Classe: PVC Esgoto; Tipo: Ramais de ventilação em cruz
Pset_PipeFittingTypeCommon - Reference: Ramais de ventilação em cruz
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Tê sanitário - 50 mm - 50 mm | PVC Esgoto - Anel de borracha - 100mm - 4" = PVC Esgoto - Tê sanitário - 100 mm - 50 mm
 | PATIO | 50mm x 50mm - 315° | Ventilação | 4 | 2
 | PAV. 02 | 100mm x 50mm - 225° | Ventilação | 3 | 1 | 1
 | PAV. 02 | 100mm x 50mm - 90° | Ventilação | 3 | 1 | 1
 | PAV. 02 | 100mm x 50mm - 225° | Esgoto | 3 | 1 | 1
 | PAV. 02 | 50mm x 50mm - 315° | Esgoto | 4 | 2

# IfcPipeFitting: Redução excêntrica (4)
Type - PredefinedType: TRANSITION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Redução excêntrica; Classe: PVC Esgoto; Tipo: Redução excêntrica
Pset_PipeFittingTypeCommon - Reference: Redução excêntrica
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" = PVC Esgoto - Redução excêntrica - 75 mm - 50 mm
 | PATIO | 100 mm - 75 mm | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Redução excêntrica - 100 mm - 75 mm: 1
 | PATIO | 75 mm - 50 mm | Esgoto | 1
 | TÉRREO | 75 mm - 50 mm | Esgoto | 1
 | PAV.01 | 75 mm - 50 mm | Esgoto | 1

# IfcPipeFitting: Redução excêntrica - superior (2)
In: PATIO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 100 mm - 75 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Redução excêntrica- superior; Nome: 100 mm - 75 mm; Classe: PVC Esgoto; Tipo: Redução excêntrica - superior
Pset_PipeFittingTypeCommon - Reference: Redução excêntrica - superior
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Redução excêntrica - 100 mm - 75 mm: 1
Name | Rede
 | Esgoto
 | Esgoto (Gordura)

# IfcPipeFitting: Te 90 soldável (36)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável
Name | In | Indicação = Nome | Rede
2 x  | PATIO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
5 x  | PATIO | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
 | PATIO | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
2 x  | TÉRREO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
4 x  | TÉRREO | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
2 x  | TÉRREO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
3 x  | TÉRREO | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
AR-1 | TÉRREO | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 40 mm: 1
4 x  | PAV.01 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
2 x  | PAV.01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
2 x  | PAV.01 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
 | PAV. 02 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
 | PAV. 02 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
4 x  | COBERTURA 01 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
 | COBERTURA 01 | 85 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 85 mm: 1
 | COBERTURA 01 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1

# IfcPipeFitting: Te 90 soldável (centro) (14)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável (centro); Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável (centro)
Name | In | Indicação = Nome | PVC rígido soldável - Tê 90 soldável - 25 mm
2 x  | PATIO | 25 mm | 1
 | TÉRREO | 60 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 60 mm: 1
3 x  | TÉRREO | 25 mm | 1
2 x  | PAV.01 | 25 mm | 1
 | PAV. 02 | 25 mm | 1
5 x  | COBERTURA 01 | 85 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 85 mm: 1

# IfcPipeFitting: Te 90 soldável c/ redução lateral (8)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável c/ redução lateral; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução lateral
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável c/ redução lateral
Name | In | Indicação = Nome | Rede
 | PATIO | 40 mm- 32mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 40 mm - 32 mm: 1; PVC rígido soldável - Tê 90 soldável - 40 mm: 1
 | PATIO | 50 mm- 32mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Tê 90 soldável - 50 mm: 1
 | PATIO | 32 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1; PVC rígido soldável - Tê 90 soldável - 32 mm: 1
AF-1 | PATIO | 50 mm- 32mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Tê 90 soldável - 50 mm: 1
 | TÉRREO | 60 mm- 50mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
2 x  | TÉRREO | 50 mm- 32mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Tê 90 soldável - 50 mm: 1
 | COBERTURA 01 | 60 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 60 mm: 1; PVC rígido soldável - Bucha de redução sold. longa - 60 mm - 25 mm: 1

# IfcPipeFitting: Te de redução 90 soldável (35)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de redução 90 soldável; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável
Pset_PipeFittingTypeCommon - Reference: Te de redução 90 soldável
Name | In | Indicação = Nome | Rede
3 x  | PATIO | 60 mm - 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1
 | PATIO | 40 mm - 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 32 mm: 1
2 x  | PATIO | 40 mm - 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 25 mm: 1
4 x  | TÉRREO | 32 mm - 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
2 x  | TÉRREO | 40 mm - 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 25 mm: 1
3 x  | TÉRREO | 60 mm - 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1
2 x  | PAV.01 | 32 mm - 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
 | PAV.01 | 60 mm - 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1
 | PAV.01 | 50 mm - 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 32 mm: 1
 | PAV.01 | 32 mm - 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
AF-1 | PAV.01 | 75 mm - 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 50 mm: 1
AF-2 | PAV.01 | 75 mm - 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 50 mm: 1
2 x  | PAV. 02 | 32 mm - 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
2 x  | PAV. 02 | 40 mm - 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 40 mm - 25 mm: 1
5 x  | COBERTURA 01 | 85 mm - 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 85 mm - 60 mm: 1
2 x  | COBERTURA 01 | 85 mm - 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 85 mm - 75 mm: 1
 | COBERTURA 01 | 60 mm - 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 50 mm: 1
 | COBERTURA 01 | 60 mm - 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 60 mm - 25 mm: 1

# IfcPipeFitting: Te de redução 90 soldável c/ redução lateral (26)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de redução 90 soldável c/ redução lateral; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável c/ redução lateral
Pset_PipeFittingTypeCommon - Reference: Te de redução 90 soldável c/ redução lateral
Name | In | Indicação = Nome | Rede
 | PATIO | 50 mm - 25 mm- 40mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 50 mm - 40 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 25 mm: 1
2 x  | PATIO | 32 mm - 25 mm- 25mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 32 mm - 25 mm: 1
