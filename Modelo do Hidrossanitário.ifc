Properties of the parts of a building model (IFC4), part 6 of 6

# IfcValve: Registro de gaveta c/canopla cromada c/PVC soldável (45)
Name | In | Nome | Metais - Registro de gaveta c/ canopla cromada - 3/4" | PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4"
3 x  | PATIO | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2
3 x  | PATIO | 1" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2
10 x  | TÉRREO | 3/4" | 1 | 2
6 x  | TÉRREO | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2
 | TÉRREO | 1" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2
4 x  | PAV.01 | 3/4" | 1 | 2
 | PAV.01 | 1" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2
3 x  | PAV.01 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2
2 x  | PAV. 02 | 1" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2
2 x  | PAV. 02 | 1.1/4" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 40 mm - 1.1/4": 2
2 x  | PAV. 02 | 3/4" | 1 | 2
 | PAV. 02 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2

# IfcValve: Registro de pressão c/ canopla cromada (8)
In: PAV. 02
Type - PredefinedType: REGULATING
AltoQi_Builder - Indicação: RP; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de pressão c/ canopla cromada; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Registro de pressão c/ canopla cromada; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de pressão c/ canopla cromada
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Registro de pressão c/ canopla cromada - 3/4": 1

# IfcValve: Registro esfera VS compacto soldável (3)
In: COBERTURA 01
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RE; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro esfera VS compacto soldável; Nome: 1.1/2"; Classe: PVC rígido soldável; Tipo: Registro esfera VS compacto soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro esfera VS compacto soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro esfera VS compacto soldável PVC - 50 mm: 1

# IfcValve: Valvula de descarga c/PVC soldável (22)
Type - PredefinedType: FLUSHING
AltoQi_Builder - Indicação: VD; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Valvula de descarga c/PVC soldável; Nome: 1.1/2"; Classe: PVC rígido soldável; Tipo: Valvula de descarga c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Valvula de descarga c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Válvula de descarga baixa pressão - 1.1/2": 1; PVC Acessórios - Bolsa de ligação p/ vaso sanitário - 1.1/2": 1; PVC Acessórios - Tubo de descarga VDE. - 38 mm: 1; PVC Acessórios - Tubo de ligação latão cromado c/ canopla p/ vaso Sa. - 38 mm: 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 1
Name | In
5 x  | PATIO
8 x  | TÉRREO
5 x  | PAV.01
4 x  | PAV. 02

# IfcWasteTerminal: Caixa Sifonada (46)
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Caixa sifonada; Descrição: Caixa Sifonada; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa Sifonada
Name | In | Comprimento (cm) | Diâmetro (cm) | Indicação = Nome | PVC Acessórios - Caixa sifonada - 150x150x50 | PVC Esgoto - Anel de borracha - 50mm - 2"
12 x  | PATIO | 15.5 | 15 | 150x150x50 | 1 | 1
 | PATIO | 18.5 | 15 | 150x185x75 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x185x75: 1; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PATIO | 10 | 10.1 | 100x100x50 |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 100x100x50: 1
10 x  | TÉRREO | 15.5 | 15 | 150x150x50 | 1 | 1
 | TÉRREO | 18.5 | 15 | 150x185x75 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x185x75: 1; PVC Esgoto - Anel de borracha - 75mm - 3": 1
3 x  | TÉRREO | 10 | 10.1 | 100x100x50 |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 100x100x50: 1
 | PAV.01 | 15.5 | 10.1 | 100x150x50 |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 100x150x50: 1
6 x  | PAV.01 | 15.5 | 15 | 150x150x50 | 1 | 1
2 x  | PAV.01 | 10 | 10.1 | 100x100x50 |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 100x100x50: 1
 | PAV.01 | 18.5 | 15 | 150x185x75 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x185x75: 1; PVC Esgoto - Anel de borracha - 75mm - 3": 1
4 x  | PAV. 02 | 15.5 | 15 | 150x150x50 | 1 | 1
3 x  | PAV. 02 | 10 | 10.1 | 100x100x50 |  | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 100x100x50: 1
 | PAV. 02 | 18.5 | 15 | 150x185x75 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x185x75: 1; PVC Esgoto - Anel de borracha - 75mm - 3": 1

# IfcWasteTerminal: Caixa de areia pluvial c/grelha (4)
In: PATIO
Type - PredefinedType: GULLYSUMP
AltoQi_Builder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CAG-60x60 cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixa de areia pluvial c/grelha; Nome: CAG-60x60 cm; Classe: Caixas de Passagem; Tipo: Caixa de areia pluvial c/grelha; Rede: Pluvial
Pset_WasteTerminalTypeCommon - Reference: Caixa de areia pluvial c/grelha
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de areia pluvial com grelha - CAG- 60x60cm: 1

# IfcWasteTerminal: Caixa de passagem (5)
In: PATIO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixa de passagem; Classe: Caixas de Passagem; Tipo: Caixa de passagem
Pset_WasteTerminalTypeCommon - Reference: Caixa de passagem
Name | Diâmetro (cm) | Indicação = Nome | Rede | Caixas de Passagem - Caixa de passagem modulada - DN 50 cm
2 x  | 57 | CE - DN 50 cm | Esgoto | 1
 | 57 | CE - DN 50 cm | Pluvial | 1
2 x  | 67 | CE - DN 60 cm | Esgoto | AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de passagem modulada - DN 60 cm: 1

# IfcWasteTerminal: Filtros, Filtro anaeróbio -1
In: PATIO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Altura do vão livre: 30 cm; Contribuição de esgoto (L/dia): 20000; Tempo de detenção (dia): 0.5; Volume útil estimado (m³): 16; Altura total do leito: 120 cm; Comprimento: 450 cm; Largura: 300 cm; Volume (m³): 16.2
Identificação_Elemento - Aplicação: Filtro anaeróbio; Nome: Filtro anaeróbio - concreto; Classe: Unidades de tratamento; Tipo: Filtros; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Filtros
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1800 cm; Unidades de tratamento - Brita - nº4: 16.2 m3; Unidades de tratamento - Concreto - Concreto: 0.2475 m3

# IfcWasteTerminal: Ralos pluviais (9)
Type - PredefinedType: FLOORTRAP
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Ralos pluviais; Classe: PVC Esgoto; Tipo: Ralos pluviais; Rede: Pluvial
Pset_WasteTerminalTypeCommon - Reference: Ralos pluviais
Name | In | Indicação = Nome | PVC Acessórios - Ralo abacaxi - 100mm
 | PAV.01 | Ralo abacaxi- 75mm | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 75mm: 1
 | PAV. 02 | Ralo abacaxi- 75mm | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 75mm: 1
 | COBERTURA 02 | Ralo abacaxi- 75mm | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 75mm: 1
2 x  | COBERTURA 02 | Ralo abacaxi- 100mm | 1
AP-11 | COBERTURA 02 | Ralo abacaxi- 100mm | 1
AP-14 | COBERTURA 02 | Ralo abacaxi- 100mm | 1
AP-15 | COBERTURA 02 | Ralo abacaxi- 100mm | 1
AP-16 | COBERTURA 02 | Ralo abacaxi- 100mm | 1

# IfcWasteTerminal: Tanques sépticos, Tanque séptico -1
In: PATIO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Intervalo entre limpezas: 2 anos; Número de câmaras: Câmara múltipla; Contribuição de esgoto (L/dia): 20000; Contribuição de lodo (L/dia): 80; Taxa de acumul. do lodo (dias/intervalo): 105; Tempo de detenção (dia): 0.5; Volume útil estimado (m³): 19.4; Comprimento: 470 cm; Largura: 235 cm; Profundidade útil: 180 cm; Volume (m³): 19.88
Identificação_Elemento - Aplicação: Tanque séptico; Nome: Tanque séptico - concreto; Classe: Unidades de tratamento; Tipo: Tanques sépticos; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Tanques sépticos
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 160.6 cm; Unidades de tratamento - Alça - Ferro: 2; Unidades de tratamento - Concreto - Concreto: 7.1205 m3; Unidades de tratamento - Tampa - Hermética: 2
