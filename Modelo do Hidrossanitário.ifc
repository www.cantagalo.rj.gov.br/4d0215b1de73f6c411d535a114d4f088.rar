Properties of the parts of a building model (IFC4), part 3 of 6

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (405)
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 67.96 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 67.9649 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 50.61 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.6075 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 49.48 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 49.4834 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 674.57 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 674.574 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 2
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 92.77 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 92.7662 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 77.63 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 77.6348 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 17.43 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 17.4293 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 260.03 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 260.025 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 97.99 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 97.9856 cm
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 93.01 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 93.0097 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 32.72 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 32.7228 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 0.89 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 606.93 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 606.927 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 2
 | PATIO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 45.35 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.3491 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 20.12 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 20.1152 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 32.12 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 32.1152 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 35.02 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 35.0182 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 131.86 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 131.861 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 15.85 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 15.8487 cm
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 63.23 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 63.2311 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 27.21 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 27.2123 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 46 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 46.0038 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 404.34 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 404.336 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 423.94 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 423.945 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PATIO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 1 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 22.86 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 22.8618 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 156.37 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 156.373 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 153.79 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 153.79 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 304.22 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 304.215 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 97.64 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 97.6445 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1374.85 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1374.85 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 4
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 29.47 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 29.4724 cm
 | PATIO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 144.81 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 144.815 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 18.11 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.1069 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 14.07 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.0742 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 24.42 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 24.4246 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 9.2 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 9.19859 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 152.6 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 152.599 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 206.7 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 206.697 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 51.68 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 51.6782 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 8.94 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.94188 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 30.37 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 30.3674 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 12.44 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 12.4381 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 14.13 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.1319 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 38.47 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 38.4672 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.88 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 23.8769 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | -1.44 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": -1.4435 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 6.53 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.52887 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 142.78 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 142.78 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 64.08 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 64.0823 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 14.77 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.7708 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 72.43 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 72.4256 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 43.58 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 43.5838 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 51.08 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 51.0782 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.42 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 23.4245 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 6.41 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.40813 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 183.77 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 183.771 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 76.99 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 76.9935 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 101.82 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 101.821 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.38 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.3789 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.38 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.3778 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 17.47 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 17.4687 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 48.37 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 48.3715 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 21.4 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 21.3989 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 24.91 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 24.9139 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.93 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.92887 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 203.86 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 203.858 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2.84 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2.83813 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 2.7 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 2.69515 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 5.02 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.01593 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 57.58 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.5781 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 54.83 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 54.827 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 28.78 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 28.778 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 14.74 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.743 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 4.96 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 4.95716 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 158.01 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 158.01 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 50.13 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 50.1251 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 286.1 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 286.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 3.74 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 3.74304 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 17.65 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 17.6508 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 34.09 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 34.0921 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1038.84 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1038.84 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 3
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 219.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 219.296 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.62 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.61977 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 108.27 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 108.272 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 8.96 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.96099 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 283.1 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 283.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.38 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.37994 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 403.09 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 403.089 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 289.7 | 50 mm - 2" | Esgoto (Gordura) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 289.7 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 280.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 280.3 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 13.28 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 13.2787 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 109.53 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 109.532 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 186.12 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 186.121 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 18.77 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 18.7741 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 5.02 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 5.02103 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 87.36 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 87.3626 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 13.48 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 13.4797 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 20.62 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 20.6226 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 14.23 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.23 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 2.1 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 2.1 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 216.27 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 216.269 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 260.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 260.3 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 14 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 128.84 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 128.842 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 25.72 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 25.7249 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 45.95 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.9469 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 182.25 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 182.249 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 16.89 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.8857 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 14.07 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.0703 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 293.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 293.8 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 60.39 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60.3946 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 47.4 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 47.3978 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 91.29 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 91.287 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 155.12 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 155.116 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 111.46 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 111.465 cm
 | TÉRREO | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 286.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 286.6 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 283.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 283.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
4 x  | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 294.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 294.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 80.63 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 80.6255 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 136.31 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 136.313 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 106.31 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 106.307 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 57.51 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.5092 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 89.36 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 89.3649 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 6.89 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.88597 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 17.02 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.0187 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 4.89 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 4.89088 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 50.82 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.8216 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 14.88 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.8849 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 107.98 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 107.977 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 85.95 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 85.9488 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 10.78 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 10.7791 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 65.21 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 65.2107 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 44.69 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 44.6884 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 6.35 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.35034 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 15.05 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.0478 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 145.31 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 145.312 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 8.37 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.37422 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 24.42 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 24.4246 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 9.2 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 9.19859 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 152.6 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 152.599 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 206.7 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 206.697 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 51.68 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 51.6782 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 8.94 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.94188 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 30.37 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 30.3674 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 12.44 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 12.4381 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 14.13 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.1319 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 38.47 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 38.4672 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.88 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 23.8769 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | -1.44 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": -1.4435 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 6.53 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.52887 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 142.78 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 142.78 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 64.08 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 64.0823 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 16.87 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 16.8708 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 72.43 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 72.4256 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 43.58 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 43.5838 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 51.08 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 51.0782 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.42 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 23.4245 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 6.01 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.00812 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 183.77 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 183.771 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 76.99 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 76.9935 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 101.82 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 101.821 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 18.11 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.1069 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 12.38 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.3789 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 100.35 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 100.348 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 7.38 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 7.3778 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 17.47 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 17.4687 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 48.37 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 48.3715 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 21.4 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 21.3989 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 24.91 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 24.9139 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.93 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.92887 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 203.86 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 203.858 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2.84 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2.83813 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 2.7 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 2.69515 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 5.02 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.01593 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 57.58 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.5781 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 54.83 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 54.827 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 35.75 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 35.7476 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 336.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 336.3 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 334.6 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 334.6 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 325.7 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 325.7 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 333 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 333 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 339.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 339.8 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 337.2 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 337.2 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 329.7 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 329.7 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 339.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 339.8 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 188.93 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 188.932 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 1028.32 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 1028.32 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 3
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 181.07 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 181.065 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 266.78 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 266.784 cm
 | PAV.01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 12.3 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 12.2958 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 601.26 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 601.26 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 2
2 x  | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 346 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 346 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 335 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 335 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 35.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 35.6 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 16.59 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 16.5902 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 16.14 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 16.1428 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 248.62 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 248.622 cm
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 17.02 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 17.0162 cm
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 339.9 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 339.9 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 340.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 340.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV.01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 341.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 341.6 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 18.26 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 18.2613 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 24.5 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 24.5039 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 75.44 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 75.4358 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 223.33 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 223.335 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 280.31 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 280.311 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 65.29 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 65.2876 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 5.43 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.42808 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 16.37 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.3654 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 18.41 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 18.4075 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 8.1 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 8.1023 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 50.58 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.5829 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 148.56 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 148.558 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 47.88 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 47.8829 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 13.67 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 13.6746 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 78.65 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 78.6502 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 13.42 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 13.4233 cm
2 x  | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 35.6 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 35.6 cm
2 x  | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 20.18 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 20.1843 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 11.85 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 11.8464 cm
2 x  | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 18.14 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 18.1416 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 271.43 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 271.427 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 14.22 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 14.2166 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 55.27 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 55.2687 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 13.01 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 13.0097 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 32.17 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.1686 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 20.92 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 20.9217 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 23.2 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 23.2039 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 166.55 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 166.551 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 46.29 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 46.2907 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 8.42 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.41559 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 46.31 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 46.3097 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 20.24 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 20.2361 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 16.12 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.1186 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 34.63 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 34.6252 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 21.73 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 21.7347 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 26.13 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 26.1252 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 40.34 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 40.3399 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 56.86 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 56.861 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 84.45 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 84.4532 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.86 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.8585 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 2.97 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 2.97478 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 49.18 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 49.1783 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 14.88 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.8849 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 19.19 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 19.1907 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 83.43 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 83.4292 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 109.22 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 109.221 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 10.78 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 10.7791 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 67.71 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 67.7107 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 46.09 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 46.0884 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 8.45 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 8.45034 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 2.68 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 2.68484 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 15.05 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.0478 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 147.21 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 147.213 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 8.67 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.67422 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 333.7 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 333.7 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 4.68 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 4.67778 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 50.78 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 50.777 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 338.6 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 338.6 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 336.9 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 336.9 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 339 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 339 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 359.1 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 359.1 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
