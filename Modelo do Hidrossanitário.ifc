Properties of the parts of a building model (IFC4), part 4 of 6

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (405)
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 345.6 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 345.6 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 333.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 333.8 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 25.27 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 25.274 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | -3.79 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -3.78523 cm
 | PAV. 02 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 4.1 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 4.1 cm
4 x  | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 15.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 15.6 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 20.13 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 20.1275 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 718.97 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 718.967 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 2
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 76.19 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 76.186 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 921.11 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 921.108 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 3
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 12.03 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 12.0275 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 4.23 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 4.23356 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 336.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 336.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 3 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 3 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 343.9 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 343.9 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 35.6 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 35.6 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 10.96 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 10.9638 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | -10.56 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -10.5629 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 9.95 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 9.94549 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 25.14 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 25.1439 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 358.3 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 358.3 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 448.11 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 448.109 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | -6.74 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -6.74135 cm
 | PAV. 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 346.2 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 346.2 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 350 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 350 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 30.36 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 30.359 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 240.91 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 240.911 cm
 | PAV. 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 328.2 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 328.2 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 425.9 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 425.9 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | COBERTURA 01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 348 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 348 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | COBERTURA 01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 347.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 347.8 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | COBERTURA 01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 332.8 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 332.8 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | COBERTURA 01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 2 | 640.2 | 75 mm - 3" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 640.2 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 2
 | COBERTURA 01 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 236.9 | 50 mm - 2" | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 236.9 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 92.96 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 92.9598 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 146.33 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 146.327 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 112.95 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 112.949 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.11 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.10565 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | -1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": -1 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7 cm
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 499.25 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 499.249 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 170.51 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 170.515 cm
 | COBERTURA 01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 11.63 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 11.6323 cm
 | COBERTURA 01 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 341.2 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 341.2 cm; PVC Esgoto - Anel de borracha - 75mm - 3": 1
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 343.2 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 343.2 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 329.9 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 329.9 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 343.03 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 343.031 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 388.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 388.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 01 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 340.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 340.1 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 02 | 296.1 | 7.21 | ø3" | 0.17 | ø75 | 1 | 109.31 | 75 mm - 3" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 109.31 cm
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 34.1 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 34.1 cm
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 5.06 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 5.05797 cm
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 162.87 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 162.867 cm
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 357.49 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 357.495 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 349 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 349 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 36.26 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 36.2633 cm
 | COBERTURA 02 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 357 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 357 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1

# IfcPipeSegment: Tubos - diâmetro interno comercial (714)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede
5 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 7 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 7 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 23.38 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 23.3815 cm
3 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 12.9 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.9 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 10.6 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 10.6 cm
2 x  | PATIO | 2.78 | ø1" | 0.21 | ø32 | 84.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 84.9 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 44.15 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 44.15 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 28.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 28.4 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 75.95 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 75.9498 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 12.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.7404 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 65.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.8 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 57.49 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 57.4883 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 69.33 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 69.3253 cm
3 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 17.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 17.25 cm
3 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 10.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.8 cm
8 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 85.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 85.4 cm
4 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 115.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 115.4 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 20.59 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 20.591 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 86.09 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86.0888 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 86.12 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86.1207 cm
3 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 94.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 94.05 cm
3 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 44.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.05 cm
 | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 99.59 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 99.5898 cm
3 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.615 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 10.76 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.7589 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 159.68 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 159.682 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 10.71 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.7101 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 10.11 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.1147 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 64.45 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 64.45 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 146.33 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 146.335 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 105.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 105.25 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 22.88 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 22.8817 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 10.33 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.3261 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 105.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 105.8 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 276.9 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 276.903 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 64.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 64.9 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 65.6 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 65.6 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 217.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 217.25 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 10.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.4 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 90.65 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 90.65 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 9.56 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 9.55942 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 62.85 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 62.8502 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 47.39 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 47.392 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 36.7 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 36.7032 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 22.17 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 22.1704 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 25.59 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 25.5933 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 20.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 20.2507 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 122.65 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 122.65 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 77.5 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 77.5 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 766.56 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 766.555 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 243.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 243.744 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 557.29 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 557.294 cm
 | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 63.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 63.6185 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 775.79 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 775.794 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 54.3 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 54.298 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 215.38 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 215.384 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 19.01 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 19.0131 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 182.83 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 182.826 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 469.55 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 469.555 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 29.46 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 29.4594 cm
 | PATIO | 3.52 | ø1 1/4" | 0.24 | ø40 | 312.3 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 312.3 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 146.46 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 146.459 cm
2 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 345.21 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 345.215 cm
 | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 214.86 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 214.859 cm
 | PATIO | 3.52 | ø1 1/4" | 0.24 | ø40 | 166.4 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 166.4 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 195.15 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 195.149 cm
 | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 30.47 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 30.4693 cm
 | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 21.74 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 21.7419 cm
 | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 15 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 15 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 2.58 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 2.58262 cm
 | PATIO | 3.52 | ø1 1/4" | 0.24 | ø40 | 302 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 302 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 388.91 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 388.91 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 6.52 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 6.52428 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 48.6 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 48.5984 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 43.77 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 43.7662 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 215.42 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 215.418 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 327 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 327 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 55 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 55 cm
 | PATIO | 5.34 | ø2" | 0.33 | ø60 | 17 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 17 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 27.36 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 27.3643 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 426.32 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 426.317 cm
 | PATIO | 3.52 | ø1 1/4" | 0.24 | ø40 | 182.28 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 182.279 cm
 | PATIO | 3.52 | ø1 1/4" | 0.24 | ø40 | 16.83 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 16.8254 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 32.94 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 32.9425 cm
 | PATIO | 2.78 | ø1" | 0.21 | ø32 | 476.68 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 476.68 cm
2 x  | PATIO | 2.78 | ø1" | 0.21 | ø32 | 247.8 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 247.8 cm
 | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 116 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 116 cm
 | PATIO | 3.52 | ø1 1/4" | 0.24 | ø40 | 35 | 40 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 35 cm
2 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 19.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 19.6 cm
2 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 36.69 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 36.6879 cm
2 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 109.65 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 109.65 cm
2 x  | PATIO | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.52 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.515 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 34.57 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 34.5671 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 88.17 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 88.1688 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 22.85 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 22.8497 cm
2 x  | PATIO | 2.16 | ø3/4" | 0.17 | ø25 | 13.5 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 13.5 cm
10 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 85.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 85.4 cm
4 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 116 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 116 cm
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 10.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.8 cm
4 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 115.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 115.4 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 116.65 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 116.65 cm
6 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 94.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 94.05 cm
3 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 62.06 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 62.065 cm
8 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 7 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 7 cm
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 15.1 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 15.1 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 15.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 15.4 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 14.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.7409 cm
5 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 12.9 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.9 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 149.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 149.25 cm
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 15.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 15.8 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 34.56 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 34.5554 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 79.63 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 79.6307 cm
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 13.5 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 13.5 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 31.44 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 31.4373 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 32.06 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 32.0552 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 33.98 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 33.984 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 78.23 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 78.2329 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 33.02 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 33.0225 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 33.47 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 33.467 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 154.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 154.25 cm
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 10.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.4 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 14.82 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.8217 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 140.08 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 140.084 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 16.12 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 16.1214 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 290.95 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 290.95 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 292.15 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 292.15 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 7.45 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 7.45 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 38.08 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 38.0803 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 79.72 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 79.7174 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 98 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 98.0003 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 17 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 17 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 35.83 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 35.8276 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 533.9 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 533.9 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 23.45 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 23.4516 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 16.75 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 16.7548 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 130.57 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 130.568 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 29.7 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 29.7 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 6.81 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 6.80809 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 40.05 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 40.0509 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 26.05 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 26.0509 cm
 | TÉRREO | 5.34 | ø2" | 0.33 | ø60 | 63 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 63 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 347.91 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 347.906 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 897.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 897.6 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 344.36 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 344.361 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 21.75 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 21.7501 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 115.12 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 115.122 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 304.6 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 304.6 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 244.73 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 244.726 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 115.47 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 115.472 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 294.5 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 294.5 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 355 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 355.005 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 44.65 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 44.65 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 918.1 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 918.1 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 145.99 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 145.987 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 154.12 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 154.121 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 673.15 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 673.155 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 15.31 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 15.3102 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 535.4 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 535.401 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 1005.81 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 1005.81 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 166.28 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 166.285 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 69.49 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 69.4929 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 21.79 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 21.7853 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 759.76 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 759.76 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 257.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 257.736 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 165.7 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 165.705 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 27.05 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 27.0531 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 28.13 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 28.1328 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 25.97 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 25.9723 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 18.14 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 18.1394 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 250.01 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 250.007 cm
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 31.34 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 31.34 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 331.83 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 331.826 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 383.09 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 383.092 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 4.48 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 4.47734 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 265.8 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 265.8 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 373.51 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 373.511 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 17.12 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 17.1205 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 1117.79 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 1117.79 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 33.27 | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 33.2686 cm
5 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 237.9 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 237.9 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 19.87 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 19.8676 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 337.88 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 337.882 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 23.06 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 23.0557 cm
6 x  | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 237.8 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 237.8 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 59.57 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 59.5733 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 250.08 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 250.082 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 40.94 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 40.936 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 29.17 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 29.1675 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 207.46 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 207.464 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 50.54 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 50.5364 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 236.16 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 236.161 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 10.12 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 10.1232 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 258.05 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 258.045 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 159.33 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 159.33 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 26.33 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 26.3343 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 32.59 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 32.5861 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 169.94 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 169.944 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 16.43 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 16.4284 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 48.97 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 48.9747 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 52.37 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 52.371 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 50.6 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 50.6 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 151.67 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 151.673 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 106.48 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 106.478 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 17.58 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 17.5756 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 68.52 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 68.5188 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 340.46 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 340.462 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 275.16 | 25 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 275.16 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 18.08 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.0787 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 26.35 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 26.3515 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 395.15 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 395.149 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 25.85 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 25.8515 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 12.42 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 12.4214 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 135.62 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 135.622 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 186.04 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 186.039 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 53.55 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 53.5483 cm
2 x  | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 10.58 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 10.5787 cm
2 x  | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 116.03 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 116.029 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 38.56 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 38.5574 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 18.18 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.1787 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 39.16 | 32 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 39.1574 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 520.31 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 520.307 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 15.7 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 15.7 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 116.25 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 116.25 cm
 | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 305.2 | 40 mm | Água fria (Reúso) | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 305.2 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 23.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 23.6 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 44.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.05 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 47.59 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 47.5886 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 109.23 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 109.232 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.62 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.615 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 12.52 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.515 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 14.6 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 14.6 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 84.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 84.9 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 44.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 44.9 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 24.63 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 24.632 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 73.65 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 73.6498 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 14.28 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.2797 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 65.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.8 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 54.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 54.8024 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 69.33 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 69.3253 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 69.58 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 69.5753 cm
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 26.45 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 26.45 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 14.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.8 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 30.34 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 30.3358 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 86 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 86.3 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 86.3034 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 44.04 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.0433 cm
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 21.4 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 21.4001 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 65.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 65.4 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 82.46 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 82.4636 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 9.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.6 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 62.07 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 62.065 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 42.8 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 42.8001 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 167.65 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 167.65 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 30.21 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 30.2094 cm
3 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 94.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 94.05 cm
5 x  | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 7 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 7 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 62.07 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 62.065 cm
2 x  | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 19.38 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 19.3813 cm
4 x  | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 85.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 85.4 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 116 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 116 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 15.43 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 15.4263 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 14.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 14.7409 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 149.22 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 149.224 cm
3 x  | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 12.9 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 12.9 cm
2 x  | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 115.4 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 115.4 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 34.02 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 34.0184 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 85.01 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 85.008 cm
2 x  | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 13.5 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 13.5 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 26.78 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 26.7848 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 28.65 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 28.6472 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 205.8 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 205.8 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 33.63 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 33.6315 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 76.85 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 76.8453 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 34.54 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 34.5436 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 33.74 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 33.7384 cm
 | PAV.01 | 6.66 | ø2 1/2" | 0.42 | ø75 | 336 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 336 cm
 | PAV.01 | 6.66 | ø2 1/2" | 0.42 | ø75 | 335.9 | 75 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 335.9 cm
 | PAV.01 | 5.34 | ø2" | 0.33 | ø60 | 533.55 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 533.554 cm
 | PAV.01 | 5.34 | ø2" | 0.33 | ø60 | 63 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 63 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 352.89 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 352.89 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 349.35 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 349.345 cm
2 x  | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 145.55 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 145.55 cm
 | PAV.01 | 2.78 | ø1" | 0.21 | ø32 | 234.68 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 234.682 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 314.6 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 314.6 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 124.3 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 124.303 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 324.6 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 324.6 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 233.8 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 233.798 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 650.5 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 650.5 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 603.27 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 603.269 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 151.22 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 151.215 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 895.89 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 895.889 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 647.56 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 647.561 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 13.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 13.5995 cm
 | PAV.01 | 2.16 | ø3/4" | 0.17 | ø25 | 673.37 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 25 mm: 673.374 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 20.85 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 20.849 cm
 | PAV.01 | 4.4 | ø1 1/2" | 0.3 | ø50 | 21.58 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 21.5824 cm
 | PAV.01 | 5.34 | ø2" | 0.33 | ø60 | 8.1 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 8.10237 cm
 | PAV.01 | 5.34 | ø2" | 0.33 | ø60 | 37.73 | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 37.7344 cm
